# Keil uVision project Project.uvprojx, settings and files
target 2.4G_Remote_CTRL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\User;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\CMSIS\Device\PY32F0xx\Source\arm;..\Drivers\PY32F002B_HAL_Driver\Inc;..\Doc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Drivers/CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f002xx.s
  group User
    ../User/: main.c py32f002b_it.c py32f002b_hal_msp.c system_py32f002b.c app.c key.c
  group Bsp
    ../User/led/: bsp_gpio_led.c
    ../User/systick/: bsp_systick_delay.c
    ../User/usart/: bsp_usart_debug.c
    ../User/tim1/: bsp_tim1.c
    ../User/2_4G/: bsp_rf_xn297.c
    ../User/adc/: bsp_adc.c
    ../User/beer/: bsp_beer.c
  group PY32F002B_HAL_Driver
    ../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.1.2
