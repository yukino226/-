# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\Drivers\PY32F002B_HAL_Driver\Inc;..\..\Bsp;..\..\Device;..\..\Hal;..\..\User;..\..\Filter;..\..\Madgwick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./: startup_py32f002bxx.s
    ../Src/: system_py32f002b.c
  group Application/User
    ../Src/: main.c py32f002b_hal_msp.c py32f002b_it.c
  group Drivers/PY32F002B_HAL_Driver
    ../../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c
  group Doc
    ../: readme.txt
  group Bsp
    ../../Bsp/: bsp.c bsp_i2c.c bsp_spi.c bsp_pwm.c bsp_flash.c bsp_timer.c bsp_adc.c
  group Device
    ../../Device/: dev_tcbp001.c dev_mpu6887.c dev_xn297l.c
  group Hal
    ../../Hal/: hal_baro.c hal_mpu.c
  group User
    ../../User/: commom.c App_Ahrs.c App_Storage.c App_Attitude_Ctl.c App_High_Ctl.c App_Motor.c App_Plane.c App_Led.c App_Sound.c App_Voltage.c
  group Filter
    ../../Filter/: Filter_LPF.c
  group Madgwick
    ../../Madgwick/: MadgwickAHRS.c
software components: CMSIS:CORE 5.2.0
